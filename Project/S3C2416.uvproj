# Keil uVision project S3C2416.uvproj, settings and files
target S3C2416 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: S3C2416 Samsung
  cpu: IRAM(0x40000000-0x4000FFFF) IROM(0x00000000-0x00007FFF) CPUTYPE(ARM926EJ-S)
  output: S3C2416 +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\@L.bin"
  AfterMake: fromelf -c ".\Objects\@L.axf" -o  ".\@L.asm"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c include: ..\System;..\eurocode;..\Apps;..\Fatfs
  memory RVCT1: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x40000000 size 0x10000
  scatter file: ..\System\s3c2416.sct
  group Apps
    ../Apps/: main.c Driver.c RTC.c
  group System
    ../System/: Exception.c MMU.c NAND.c LowLevelInit.s s3c2416.s UART2416.C Timer_IRQ.c WDC.c adc.c Hsmmc.c
  group user
    ../eurocode/: yqadc.c yqcoin.c yqfile.c yqscreen.c yqsqlite3.c yqdrive.c AD_filter.c my_cmd.c log.c
  group Abstract
    ./: README.TXT
  group FatFs
    ../Fatfs/: diskio.c ff.c
    ../Fatfs/option/: ccsbcs.c
